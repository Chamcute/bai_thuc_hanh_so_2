# Keil uVision project DHT11.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DHT11
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group incl
    D:/download/: uart.h GPIO.h Delay_Tim.h DHT11.h
  group src
    D:/download/: uart.c main.c GPIO.c Delay_Tim.c DHT11.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0
